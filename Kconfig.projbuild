## Kconfig.projbuild
```kconfig
menu "Component drv_dht11 Configuration"

    config DRV_DHT11_USE
        bool "Use drv_dht11 component"
        default y
        
endmenu
```
